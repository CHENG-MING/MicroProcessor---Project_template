# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HAREWARE\GPIO_setting;..\HAREWARE\ADC;..\HAREWARE\KEY;..\HAREWARE\LED;..\HAREWARE\ITEMP;..\HAREWARE\DAC;..\HAREWARE\LCD;..\HAREWARE\STMFLASH;..\HAREWARE\GPS;..\HAREWARE\USART2;..\HAREWARE\MPU6050;..\HAREWARE\MPU6050\eMPL;..\HAREWARE\EXTI;..\HAREWARE\IWDG;..\HAREWARE\PWM;..\HAREWARE\NRF24L01;..\HAREWARE\SPI;..\HAREWARE\TIMER_INT;..\HAREWARE\TIMER_CAP;..\HAREWARE\OLED;..\HAREWARE\HC05
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HAREWARE
    ../HAREWARE/GPIO_setting/: setting.c
    ../HAREWARE/ADC/: adc.c
    ../HAREWARE/DAC/: dac.c
    ../HAREWARE/LCD/: lcd.c
    ../HAREWARE/LED/: led.c
    ../HAREWARE/KEY/: key.c
    ../HAREWARE/ITEMP/: tsensor.c
    ../HAREWARE/STMFLASH/: stmflash.c
    ../HAREWARE/GPS/: gps.c
    ../HAREWARE/USART2/: usart2.c
    ../HAREWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HAREWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HAREWARE/EXTI/: exti.c
    ../HAREWARE/IWDG/: iwdg.c
    ../HAREWARE/PWM/: pwm.c
    ../HAREWARE/NRF24L01/: 24l01.c
    ../HAREWARE/SPI/: spi.c
    ../HAREWARE/TIMER_INT/: timer_int.c
    ../HAREWARE/TIMER_CAP/: timer_cap.c
    ../HAREWARE/HC05/: hc05.c
